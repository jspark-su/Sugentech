# IAR project SMART_Main_FW.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C8 STM8L152C8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x550
  General.GenHeapSize: 0x300
  ICCSTM8.CCIncludePath2: inc; src; Std_Libraries; Std_Libraries\inc; Std_Libraries\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: SMART_Main_FW.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker\SMART_Main_App_lnkstm8l152c8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Inc
    inc/: Device_Initial_Check.h Device_Setup.h FW_Version_Info.h main.h stm8l15x.h stm8l15x_it.h
  group Library/Inc
    Std_Libraries/inc/: stm8l15x_adc.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_itc.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rtc.h stm8l15x_syscfg.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_usart.h
  group Library/Src
    Std_Libraries/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_usart.c
  group Src
    src/: Device_Initial_Check.c Device_Setup.c main.c stm8_interrupt_vector.c stm8l15x_it.c
  group User/Inc/API
    inc/: API_Message_Ctrl.h CircularQueue.h Parson.h Uart_Ctrl.h
  group User/Inc/BLE
    inc/: BLE_BoT_nLE521.h BLE_Ctrl.h BLE_RF_BM_4044B4.h
  group User/Inc/Device_Mode
    inc/: admin_mode.h Production_Mode.h User_Mode.h
  group User/Inc/Etc
    inc/: Delay.h
  group User/Inc/Module_Control
    inc/: battery_ctrl.h lcd_ctrl.h LED_Ctrl.h Memory_Ctrl.h PTR_Ctrl.h Temperature_Ctrl.h time_ctrl.h
  group User/Src/API
    src/: API_Message_Ctrl.c CircularQueue.c Parson.c uart_ctrl.c
  group User/Src/BLE
    src/: BLE_BoT_nLE521.c BLE_Ctrl.c BLE_RF_BM_4044B4.c
  group User/Src/Device_Mode
    src/: admin_mode.c Production_Mode.c User_Mode.c
  group User/Src/Etc
    src/: Delay.c
  group User/Src/Module_Control
    src/: Battery_Ctrl.c lcd_ctrl.c led_ctrl.c memory_ctrl.c ptr_ctrl.c temperature_ctrl.c time_ctrl.c
